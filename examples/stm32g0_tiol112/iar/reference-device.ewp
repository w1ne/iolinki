# IAR project reference-device.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 39
  General.OGChipSelectEditMenu: STM32G0B1RE ST STM32G0B1RE
  General.FPU2: 4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32G0B1xx
  ICCARM.CCIncludePath2: ..; ..\..\reference_device; ..\..\..\include; $STM32_CMSIS_ROOT$\Include; $CMSIS_CORE_ROOT$\Include
  ICCARM.IccLang: 0
  ICCARM.CCOptLevel: 2
  AARM.AUserIncludes: $STM32_CMSIS_ROOT$\Include; $CMSIS_CORE_ROOT$\Include
  ILINK.IlinkIcfFile: stm32g0b1re.icf
  ILINK.IlinkOutputFile: reference-device.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: main.c board.c rx_queue.c
    ../../reference_device/: reference_device.c
  group IO-Link stack
    ../../../src/: phy_tiol112.c crc.c frame.c dll.c isdu.c events.c params.c data_storage.c device_info.c device.c
  group ST CMSIS
    $STM32_CMSIS_ROOT$/Source/Templates/: system_stm32g0xx.c
    $STM32_CMSIS_ROOT$/Source/Templates/iar/: startup_stm32g0b1xx.s
